Commit message: add obstacle urdf

File: assets/stair_obstacle.urdf (robot description, URDF)
Before this commit: robot stair_obstacle, 1 links, 0 joints
Links:
- link stairs: geometry collision box size=0.2 2.2 0.01; collision box size=0.2 2.2 0.02
